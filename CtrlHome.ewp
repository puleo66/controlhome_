# IAR project CtrlHome.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; APP; BSP; CPU\inc; uC-CPU; uC-RTC; uC-LIB; uCOS-II\Ports; uCOS-II\Source; I2C-Out; Direct_Sw; Wdt_led; uC-LCD; uC-RF; uC-FatFS; uC-FatFS\api; uC-FatFS\config; uC-FatFS\os; uC-FatFS\fsl\fat; uC-FatFS\clib; uC-FatFS\lbl; uC-FatFS\device\mmc; uC-FatFS\file; uC-Terminal\src; uC-Terminal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CtrlHome.hex
  ILINK.IlinkOutputFile: CtrlHome.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group App/General
    APP/: app.c app_cfg.h app_vect_v5.c controlHome.h includes.h os_cfg.h
  group App/ST
    APP/: stm32f10x_conf.h
  group BSP/General
    BSP/: bsp.c bsp.h bsp_direct_btn.c bsp_direct_btn.h bsp_green_led.c bsp_green_led.h bsp_i2ch.c bsp_i2ch.h bsp_int.c bsp_lcd.c bsp_lcd.h bsp_periph.c bsp_reset_rfm69cw.c bsp_reset_rfm69cw.h bsp_spi2.c bsp_spi2.h bsp_tmr.c bsp_tmr.h STM32_FLASH.icf
  group DIRECT_SW
    Direct_Sw/: direct_sw.c direct_sw.h
  group FWLib/inc
    CPU/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group FWLib/src
    CPU/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LED-Out
    I2C-Out/: i2cout.c i2cout.h
  group uC/CPU
    uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_def.h
  group uC/FS/api
    uC-FatFS/api/: api_dir.c api_in.c api_int.h api_misc.c api_out.c fs_api.h fs_dev.h fs_fsl.h fs_info.c fs_int.h
  group uC/FS/clib
    uC-FatFS/clib/: clibmisc.c fs_clib.h
  group uC/FS/config
    uC-FatFS/config/: fs_conf.h fs_port.h
  group uC/FS/device/mmc
    uC-FatFS/device/Mmc/: mmc_drv.c sdcmd.c sdcmd.h sdconfig.h sdcrc.c sdcrc.h sddriver.c sddriver.h
  group uC/FS/file
    uC-FatFS/file/: file_rutin.c file_rutin.h
  group uC/FS/fsl/fat
    uC-FatFS/fsl/fat/: fat_data.c fat_dir.c fat_in.c fat_ioct.c fat_misc.c fat_open.c fat_out.c fs_fat.h
  group uC/FS/lbl
    uC-FatFS/lbl/: fs_lbl.h lb_misc.c
  group uC/FS/os
    uC-FatFS/os/: fs_os.h fs_x_ucos_ii.c
  group uC/LCD
    uC-LCD/: lcd.c lcd.h lcd_os.c
  group uC/LIB
    uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    uC-LIB/: lib_ascii.c lib_ascii.h lib_mem_a.asm
  group uC/OS-II/Ports
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/RF
    uC-RF/: fs20.c fs20.h rf868.c rf868.h rfm69cw.c rfm69cw.h RFM69OOKregisters.h
  group uC/RTC
    uC-RTC/: rtc.c rtc.h
  group uC/Terminal/inc
    uc-terminal/inc/: hw_config.h terutil.h usb_conf.h usb_core.h usb_def.h usb_desc.h usb_init.h usb_int.h usb_istr.h usb_lib.h usb_mem.h usb_prop.h usb_pwr.h usb_regs.h usb_sil.h view.h
  group uC/Terminal/src
    uc-terminal/src/: hw_config.c terutil.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c usbterm.c usbterm.h view.c
  group WDT_LED
    WDT_LED/: wdtled.c wdtled.h
